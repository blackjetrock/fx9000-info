# Repository blackjetrock/fx9000-info

File README.md:

# fx9000-info
FX9000P Information

This repository has information about the FX9000P and modifications and fixes I have made to it.

Index
=====

* Cartridge Addressing including memory map
* Screen layout
* Memory dump of 4K cartridge
* Video RAM socket
* Video RAM Replacement PCB and firmware

## KiCad design pcbs/video-ram-replacement/pcb/video-ram-replacement/video-ram-replacement.kicad_pcb

Parts:
C2, C3: 27p; C_0402_1005Metric
C5, C6, C9, C10, C11, C13, C14, C15: 100n; C_0402_1005Metric
C7, C8: 1u; C_0402_1005Metric
C16, C17: 10u; C_0805_2012Metric
J1, J2: Conn_01x01_Female; SolderWirePad_1x01_SMD_1x2mm
R1: 1k; C_0402_1005Metric
R2: 10k; C_0402_1005Metric
U1: ram_4044; DIP-18_W7.62mm_Socket
U2: W25Q128JVS; SOIC-8_5.23x5.23mm_P1.27mm
U3: NCP1117-3.3_SOT223; SOT-223-3_TabPin2
U7: RP2040; RP2040-QFN-56-no_holes
Y1: ABLS-12.000MHZ-B4-T; ecx-32

Connections:
5V: C16.1, U1.18 (VCC), U3.3 (VI)
+1V1: C5.1, C6.1, C7.1, U7.23 (DVDD), U7.45 (VREG_VOUT), U7.50 (DVDD)
+3V3: C8.1, C9.1, C10.1, C11.1, C13.1, C14.1, C15.1, C17.1, R2.1, U2.8 (VCC), U3.2 (VO), U7.1 (IOVDD), U7.10 (IOVDD), U7.22 (IOVDD), U7.33 (IOVDD), U7.42 (IOVDD), U7.43 (ADC_AVDD), U7.44 (VREG_IN), U7.48 (USB_VDD), U7.49 (IOVDD)
/QSPI_SCLK: U2.6 (CLK), U7.52 (QSPI_SCLK)
/QSPI_SD0: U2.5 (DI(IO0)), U7.53 (QSPI_SD0)
/QSPI_SD1: U2.2 (DO(IO1)), U7.55 (QSPI_SD1)
/QSPI_SD2: U2.3 (IO2), U7.54 (QSPI_SD2)
/QSPI_SD3: U2.7 (IO3), U7.51 (QSPI_SD3)
/QSPI_SS: R2.2, U2.1 (~CS), U7.56 (QSPI_SS)
/XIN: C2.1, U7.20 (XIN), Y1.1
/XOUT: R1.1, U7.21 (XOUT)
A0: U1.1 (A0), U7.11 (GPIO8)
A1: U1.2 (A1), U7.12 (GPIO9)
A2: U1.3 (A2), U7.13 (GPIO10)
A3: U1.4 (A3), U7.14 (GPIO11)
A4: U1.5 (A4), U7.15 (GPIO12)
A5: U1.6 (A5), U7.16 (GPIO13)
A6: U1.17 (A6), U7.17 (GPIO14)
A7: U1.16 (A7), U7.18 (GPIO15)
A8: U1.15 (A8), U7.27 (GPIO16)
A9: U1.14 (A9), U7.28 (GPIO17)
A10: U1.13 (A10), U7.29 (GPIO18)
A11: U1.12 (A11), U7.30 (GPIO19)
CS_N: U1.10 (CS_N), U7.38 (GPIO26_ADC0)
DIN: U1.11 (DIN), U7.3 (GPIO1)
DOUT: U1.7 (DOUT), U7.2 (GPIO0)
GND: C2.2, C3.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C13.2, C14.2, C15.2, C16.2, C17.2, U1.9 (GND), U2.4 (GND), U3.1 (GND), U7.19 (TESTEN), U7.57 (GND)
unnamed: C3.1, R1.2, Y1.2
SWCLK: J2.1, U7.24 (SWCLK)
SWD: J1.1, U7.25 (SWD)
W_N: U1.8 (W_N), U7.39 (GPIO27_ADC1)

Notes on the sheet:
Crystal
Make sure C10 is close to pin 44 of RP2040
Make sure C8 is close to pin 45 of RP2040
Flash
Power

Board: 4 copper layers, 11.4 x 42.2 mm, 23 parts (11 on the bottom side), 31 nets.

## Commit log

2023-02-05 Fixed slot wiring problem
2023-02-12 Corrected CS4 and added memory map. Added 32K cartridge info
2026-05-24 "Update"
